# Keil uVision project project.uvprojx, settings and files
target rt-thread (6220000::V6.22::ARMCLANG)
  device: STM32H7S7L8Hx STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5
  c define: RT_USING_LIBC, USE_HAL_DRIVER, __STDC_LIMIT_MACROS, STM32H7S7xx, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARMLIBC
  c include: ..\..\rt-thread\components\libc\posix\io\epoll;applications;board\port;board\CubeMX_Config\Appli\Core\Inc;..\..\rt-thread\components\dfs\dfs_v1\filesystems\romfs;..\..\rt-thread\components\net\lwip\lwip-2.1.2\src\include\netif;..\..\rt-thread\components\drivers\wlan;..\..\libraries\STM32H7RSxx_HAL_Driver\Inc;..\..\rt-thread\components\finsh;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\libc\posix\io\eventfd;..\..\rt-thread\components\net\sal\include\socket\sys_socket;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;packages\wifi-host-driver-latest\wifi-host-driver;..\..\libraries\CMSIS\Include;..\..\rt-thread\components\libc\posix\io\poll;..\..\libraries\CMSIS\Device\ST\STM32H7RSxx\Include;..\..\libraries\bsp_components;packages\wifi-host-driver-latest\porting\inc\hal;..\..\rt-thread\components\net\lwip\lwip-2.1.2\src\include;packages\wifi-host-driver-latest\wifi-host-driver\WiFi_Host_Driver\resources\nvram\COMPONENT_43438\COMPONENT_AW-CU427-P;..\..\rt-thread\components\libc\posix\ipc;..\..\libraries\drivers\include\config;packages\wifi-host-driver-latest\porting\inc\bsp;..\..\libraries\samples;..\..\rt-thread\components\net\sal\impl;..\..\libraries\drivers\include;packages\wifi-host-driver-latest\wifi-host-driver\WiFi_Host_Driver\inc;..\..\libraries\drivers;..\..\rt-thread\components\net\sal\include\socket;packages\wifi-host-driver-latest\wifi-host-driver\WiFi_Host_Driver\src\bus_protocols;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\net\sal\include;..\..\rt-thread\components\libc\compilers\common\extension\fcntl\octal;..\..\rt-thread\components\dfs\dfs_v1\filesystems\elmfat;packages\wifi-host-driver-latest\porting\inc\rtos;..\..\rt-thread\components\drivers\spi;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\libc\compilers\common\include;packages\wifi-host-driver-latest\wifi-host-driver\WiFi_Host_Driver\resources\resource_imp;.;..\..\rt-thread\components\dfs\dfs_v1\include;..\..\rt-thread\components\net\lwip\port;..\..\rt-thread\components\drivers\spi\sfud\inc;board;..\..\rt-thread\components\dfs\dfs_v1\filesystems\devfs;..\..\rt-thread\libcpu\arm\cortex-m7;..\..\rt-thread\components\net\netdev\include;..\..\rt-thread\components\net\sal\include\dfs_net;..\..\rt-thread\components\libc\compilers\common\extension;..\..\rt-thread\include;packages\wifi-host-driver-latest\wifi-host-driver\WiFi_Host_Driver\src\include;..\..\rt-thread\libcpu\arm\common;packages\wifi-host-driver-latest\wifi-host-driver\WiFi_Host_Driver\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
    ./applications/: ai_chat_service.c ai_cloud_service.c ai_dialog_tool.c ai_test_tool.c audio_capture_inmp441.c audio_player.c audio_process.c audio_samples_test.c audio_test.c drv_audio_max98357a.c drv_sai_inmp441.c memory_helper.c voice_assistant.c wakeup_detector.c web_client.c
  group Compiler
    ../../rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../rt-thread/components/drivers/core/: device.c
    ../../rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rt-thread/components/drivers/mtd/: mtd_nor.c
    ../../rt-thread/components/drivers/pin/: pin.c
    ../../rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    ../../rt-thread/components/drivers/serial/: dev_serial_v2.c
    ../../rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    board/CubeMX_Config/Appli/Core/Src/: stm32h7rsxx_hal_msp.c
    board/: board.c drv_mpu.c
    board/port/: filesystem.c
    ../../libraries/drivers/: drv_common.c drv_gpio.c drv_lcd.c drv_psram.c drv_sdmmc.c drv_spi.c drv_usart_v2.c
    ./board/: cubemx_init.c
  group Filesystem
    ../../rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../rt-thread/components/dfs/dfs_v1/filesystems/romfs/: dfs_romfs.c
    ../../rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../rt-thread/components/finsh/: msh.c msh_file.c msh_parse.c cmd.c shell.c
  group Kernel
    ../../rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../rt-thread/libcpu/arm/common/: div0.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group lwIP
    ../../rt-thread/components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../rt-thread/components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    ../../rt-thread/components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../rt-thread/components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../rt-thread/components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group NetUtils
    packages/netutils-latest/iperf/: iperf.c
  group POSIX
    ../../rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group SAL
    ../../rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../rt-thread/components/net/sal/dfs_net/: dfs_net.c
    ../../rt-thread/components/net/sal/impl/: af_inet_lwip.c
    ../../rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../rt-thread/components/net/sal/src/: sal_socket.c
  group STM32_HAL
    ../../libraries/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_crc.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_crc_ex.c stm32h7rsxx_hal_cryp.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_cryp_ex.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_cec.c stm32h7rsxx_ll_sdmmc.c stm32h7rsxx_hal_usart.c stm32h7rsxx_hal_adc_ex.c stm32h7rsxx_hal_sram.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_xspi.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_sd.c stm32h7rsxx_hal_spi.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_adc.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_rng.c
    ../../libraries/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/: system_stm32h7rsxx.c
    ../../libraries/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/arm/: startup_stm32h7r7xx.s
    ./libraries/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_ltdc.c stm32h7rsxx_hal_i2s.c stm32h7rsxx_hal_sai.c stm32h7rsxx_hal_sai_ex.c
  group whd
    packages/wifi-host-driver-latest/porting/src/rtos/: whd_rtos.c
    packages/wifi-host-driver-latest/wifi-host-driver/WiFi_Host_Driver/src/: whd_network_if.c whd_wifi_api.c whd_ring.c whd_resource_if.c whd_wifi.c whd_management.c whd_chip.c whd_flowring.c whd_clm.c whd_proto.c whd_thread.c whd_cdc_bdc.c whd_wifi_p2p.c whd_logging.c whd_utils.c whd_debug.c whd_buffer_api.c whd_msgbuf_txrx.c whd_ap.c whd_chip_constants.c whd_sdpcm.c whd_events.c whd_commonring.c
    packages/wifi-host-driver-latest/porting/src/hal/: cyhal_sdio.c cyhal_gpio.c
    packages/wifi-host-driver-latest/wifi-host-driver/WiFi_Host_Driver/src/bus_protocols/: whd_bus_sdio_protocol.c whd_bus.c whd_bus_common.c
    packages/wifi-host-driver-latest/porting/src/resources/: download.c
    packages/wifi-host-driver-latest/porting/src/wlan/: whd_wlan.c
    packages/wifi-host-driver-latest/porting/src/bsp/: cybsp.c cy_network_buffer.c
    ./packages/wifi-host-driver-latest/wifi-host-driver/WiFi_Host_Driver/resources/resource_imp/: whd_resources.c
    ./packages/wifi-host-driver-latest/wifi-host-driver/WiFi_Host_Driver/resources/firmware/COMPONENT_43438/: 43438A1_bin.c
    ./packages/wifi-host-driver-latest/wifi-host-driver/WiFi_Host_Driver/resources/clm/COMPONENT_43438/: 43438A1_clm_blob.c
